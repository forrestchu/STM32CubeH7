# Keil uVision project Project.uvprojx, settings and files
target STM32H743I_EVAL (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H743I_EVAL +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_STM32H743I_EVAL,
  c include: ../Inc;../Src;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../../../../../../Drivers/CMSIS/Include;../../../../../../Drivers/STM32H7xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/Components/;../../../../../../Drivers/BSP/STM32H743I-EVAL;../../../../../../Drivers/BSP/Components/Common;../../../../../../Middlewares/Third_Party/LwIP/src/include/;../../../../../../Middlewares/Third_Party/LwIP/src/apps/;../../../../../../Middlewares/Third_Party/LwIP/system;../../../../../../Middlewares/Third_Party/FATFS_20220331/FATFS/source;../../../../../../Utilities/LCD;../../../../../../Utilities/Lcd_Trace
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: STM32H743I_EVAL\STM32H743I_EVAL.sct
  group Middlewares/LwIP/Core/IPv4
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/ipv4/: etharp.c ip4.c autoip.c dhcp.c igmp.c ip4_frag.c ip4_addr.c icmp.c
  group Application/MDK-ARM
    ./: startup_stm32h743xx.s
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/mfxstm32l152/: mfxstm32l152.c mfxstm32l152_reg.c
    ../../../../../../Drivers/BSP/Components/stmpe811/: stmpe811.c stmpe811_reg.c
    ../../../../../../Drivers/BSP/Components/lan8742/: lan8742.c
    ../../../../../../Drivers/BSP/Components/is42s32800g/: is42s32800g.c
    ../../../../../../Drivers/BSP/Components/ts3510/: ts3510.c ts3510_reg.c
  group Application/Utilities
    ../../../../../../Utilities/lcd/: stm32_lcd.c
    ../../../../../../Utilities/Lcd_Trace/: lcd_trace.c
  group Middlewares/LwIP/Api
    ../../../../../../Middlewares/Third_Party/LwIP/src/api/: err.c netdb.c api_lib.c netbuf.c sockets.c tcpip.c netifapi.c api_msg.c
  group Drivers/BSP/STM32H743I_EVAL
    ../../../../../../Drivers/BSP/STM32H743I-EVAL/: stm32h743i_eval.c stm32h743i_eval_bus.c stm32h743i_eval_io.c stm32h743i_eval_lcd.c stm32h743i_eval_sd.c stm32h743i_eval_sdram.c
  group Middlewares/LwIP/Core
    ../../../../../../Middlewares/Third_Party/LwIP/src/core/: init.c pbuf.c inet_chksum.c dns.c netif.c sys.c def.c raw.c ip.c stats.c tcp_in.c timeouts.c udp.c tcp_out.c mem.c memp.c tcp.c
  group Drivers/STM32H7xx_HAL_Driver
    ../../../../../../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_sd.c stm32h7xx_ll_delayblock.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_eth.c stm32h7xx_ll_fmc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_rcc.c stm32h7xx_ll_sdmmc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_sdram.c stm32h7xx_hal_dma.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_exti.c
  group Middlewares/FatFs/Core
    ../../../../../../Middlewares/Third_Party/FATFS_20220331/FATFS/source/: diskio.c ff.c ffsystem.c ffunicode.c sdmmc_sdcard.c sys.c
  group Application/User
    ../Src/: ethernetif.c main.c tftpserver.c app_ethernet.c stm32h7xx_it.c tftputils.c udp_console.c stm32h7xx_hal_msp.c httpc_loader.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/apps/http/: http_client.c
  group Middlewares/LwIP/Netif
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
    ../../../../../../Middlewares/Third_Party/LwIP/src/netif/ppp/polarssl/: md5.c
  group Drivers/CMSIS
    ../Src/: system_stm32h7xx.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.0.1
